## code/samples/ble/boards/Travis_Leaton/t_parasite/board.yml
```yaml
board:
  name: t_parasite
  full_name: t_parasite
  vendor: Travis_Leaton
  socs:
    - name: nrf52810
```
